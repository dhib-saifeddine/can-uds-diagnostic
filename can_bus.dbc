VERSION ""

NS_ :

BS_:

BU_: ECU_Moteur ECU_Freinage ECU_Dashboard

BO_ 256 ECU_Moteur: 8 ECU_Moteur
 SG_ RPM : 7|16@0+ (1,0) [800|4000] "rpm" ECU_Dashboard
 SG_ Temperature : 23|8@0+ (1,0) [70|110] "degC" ECU_Dashboard

BO_ 512 ECU_Freinage: 8 ECU_Freinage
 SG_ Pression : 0|8@1+ (1,0) [0|100] "%" ECU_Dashboard
 SG_ Etat : 8|8@1+ (1,0) [0|1] "" ECU_Dashboard

CM_ BU_ ECU_Moteur "Calculateur moteur : génère régime moteur (RPM) et température.";
CM_ BU_ ECU_Freinage "Calculateur de freinage : génère pression de freinage et état d'usure.";
CM_ BU_ ECU_Dashboard "Tableau de bord : agrège et affiche les données reçues des autres ECU.";
CM_ BO_ 256 "Trame ECU Moteur, émise toutes les ~1s.";
CM_ BO_ 512 "Trame ECU Freinage, émise toutes les ~1.5s.";
CM_ SG_ 256 RPM "Régime moteur, encodé big-endian (Motorola) sur 2 octets : (octet0<<8)|octet1.";
CM_ SG_ 256 Temperature "Température moteur en °C, 1 octet brut, aucun facteur d'échelle.";
CM_ SG_ 512 Pression "Pression de freinage en %, 1 octet brut, aucun facteur d'échelle.";
CM_ SG_ 512 Etat "État des freins : 0 = OK, 1 = usure détectée (probabilité 10%% côté simulation).";

VAL_ 512 Etat 0 "OK" 1 "Usure detectee" ;
